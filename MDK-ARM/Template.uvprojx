# Keil uVision project Template.uvprojx, settings and files
target Template (6240000::V6.24::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__ASM__=__asm
  c misc: -DCONFIG_FREERTOS
  c include: ../Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USP;../SRML;../USP/Middlewares/Systemview;../Drivers/CMSIS/DSP/Include;../Middlewares/FreeRTOS_port;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USP/Drivers;../USP/Application/Actuators_Space/Encoder;../USP/Application/Actuators_Space/JointActuator;../USP/Application/Actuators_Space/Motor;../USP/Application/Actuators_Space/SpecialActuators;../USP/Application/Joint_Space/Joint;../USP/Application/Joint_Space/Traj;../USP/Application/StateMachine;../USP/Application/Compension;../USP/Application/Communication;../USP/Application/Controller;../USP/Application/Claw;../USP/Middlewares/StateMachine_Kit;../USP/Middlewares/RGB_Kit;../USP/Middlewares/Robotic_Kit;../USP/Middlewares/Servo_Kit;../USP/Application/Move
  asm include: ..\Core\Inc;../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\STM32F405RGT6.sct
  group USP
    ../USP/: srml_config.h
  group USP/Application
    ../USP/: internal.h
    ../USP/Application/: Service_Communication.cpp Service_Debug.cpp Service_Device.cpp System_Config.cpp System_DataPool.cpp
  group USP\Application\StateMachine
    ../USP/Application/StateMachine/: LostState.cpp LostState.h MobileState.cpp MobileState.h TopState.cpp TopState.h ExchangeEnergyUnit.cpp ExchangeEnergyUnit.h GetEnergyUnit.cpp GetEnergyUnit.h
  group USP\Application\Actuators_Space\Encoder
    ../USP/Application/Actuators_Space/Encoder/: Encoder.cpp Encoder.h
  group USP\Application\Actuators_Space\JointActuator
    ../USP/Application/Actuators_Space/JointActuator/: JointActuator.cpp JointActuator.h
  group USP\Application\Actuators_Space\Motor
    ../USP/Application/Actuators_Space/Motor/: DJI_motor.cpp DJI_motor.h DM_motor.cpp DM_motor.h Motor.cpp Motor.h
  group USP\Application\Actuators_Space\SpecialActuators
    ../USP/Application/Actuators_Space/SpecialActuators/: Special_Actuator1.cpp Special_Actuator1.h Special_Actuator2.cpp Special_Actuator2.h Special_Actuator3.cpp Special_Actuator3.h
  group USP\Application\Joint_Space\Joint
    ../USP/Application/Joint_Space/Joint/: Joint.cpp Joint.h
  group USP\Application\Joint_Space\Traj
    ../USP/Application/Joint_Space/Traj/: cqc.h cubic_spline.h Linear.cpp Linear.h Trajectory.cpp Trajectory.h
  group USP\Application\Communication
    ../USP/Application/Communication/: ChassisCom.cpp ChassisCom.h CustomCom.cpp CustomCom.h VisualCom.cpp VisualCom.h
  group USP\Application\Controller
    ../USP/Application/Controller/: CustomControl.cpp CustomControl.h Keyboard.cpp Keyboard.h VisualControl.cpp VisualControl.h ActionGroupController.cpp ActionGroupController.h
  group USP\Application\Claw
    ../USP/Application/Claw/: Claw.cpp Claw.h
  group USP\Application\Move
    ../USP/Application/Move/: ActionGroup.cpp ActionGroup.h
  group USP\Application\Compension
    ../USP/Application/Compension/: Compension.cpp Compension.h
  group USP\Middlewares\StateMachine_Kit
    ../USP/Middlewares/StateMachine_Kit/: hfsm.h
  group USP\Middlewares\RGB_Kit
    ../USP/Middlewares/RGB_Kit/: Indicator.cpp Indicator.h RGB_led.cpp RGB_led.h WS2812.cpp WS2812.h
  group USP\Middlewares\Robotic_Kit
    ../USP/Middlewares/Robotic_Kit/: Robotic_Math .cpp Robotic_Math.h
  group USP\Middlewares\Servo_Kit
    ../USP/Middlewares/Servo_Kit/: Servo.cpp Servo.h
  group USP/Middlewares/SystemView
    ../USP/Middlewares/Systemview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group SRML
    ../SRML/: SRML.h srml_std_lib.h srml_std_lib.cpp
  group SRML/Middlewares/Abstract_class_library
    ../SRML/Middlewares/Abstract_class_library/: abstractIMU.h abstractMotor.h
  group SRML/Middlewares/Algorithm
    ../SRML/Middlewares/Algorithm/MultiTurnRecorder/: MultiTurnRecorder.h
    ../SRML/Middlewares/Algorithm/Filters/: filters.h SecondButterworthLPF.h
    ../SRML/Middlewares/Algorithm/DiffCalculator/: DiffCalculator.h
    ../SRML/Middlewares/Algorithm/PID/: PID.cpp
    ../SRML/Middlewares/Algorithm/filters/: filters.cpp
    ../SRML/Middlewares/Algorithm/KalmanFilter/: kalman_filter.h
    ../SRML/Middlewares/Algorithm/Statistics/: statistics.h
  group SRML/Middlewares/Module
    ../SRML/Middlewares/Module/Chassis/: chassis.cpp MecenumChassis.cpp
    ../SRML/Middlewares/Module/Digital_Power/: digital_Power.cpp DP_power_ctrl.cpp
    ../SRML/Middlewares/Module/Digital_Power_V2/: Digital_Power_V2.cpp
    ../SRML/Middlewares/Module/Digital_Power_V3/: Digital_Power_V3.cpp
  group SRML/Middlewares/Protocol
    ../SRML/Middlewares/Protocol/: SerialLineIP.cpp
  group SRML/Middlewares/Utility
    ../SRML/Middlewares/Utility/: sys_analysis.cpp sys_log.cpp
    ../SRML/Middlewares/Utility/VofaMonitor/: VofaMonitor.cpp
    ../SRML/Middlewares/Utility/UpperMonitor/: UpperMonitor.cpp
    ../SRML/Middlewares/Utility/AsuwaveMonitor/: AsuwaveMonitor.cpp
    ../SRML/Middlewares/Utility/Easylogger/: elog_port.cpp elog.c elog_utils.c
  group SRML/Drivers/Components
    ../SRML/Drivers/Components/: drv_can.c drv_flash.c drv_i2c.c drv_spi.c drv_timer.c drv_VirtualCom.c drv_uart.cpp drv_memory.cpp SRML_Timer.cpp
  group SRML/Drivers/Devices
    ../SRML/Drivers/Devices/DR16/: dr16.cpp
    ../SRML/Drivers/Devices/Referee/: referee.cpp
    ../SRML/Drivers/Devices/FS_I6X/: FS_I6X.cpp
    ../SRML/Drivers/Devices/VT13/: vt13.cpp
  group SRML/Drivers/Devices/IMU
    ../SRML/Drivers/Devices/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_component.c mpu6050.c
    ../SRML/Drivers/Devices/Lpms_Be2/: LPMS_BE2.cpp
  group SRML/Drivers/Devices/Motor
    ../SRML/Drivers/Devices/Motor_Dji/: motor_dji.h
    ../SRML/Drivers/Devices/HT_04/: HT04.cpp
    ../SRML/Drivers/Devices/MF9025_V2/: MF9025_v2.cpp
    ../SRML/Drivers/Devices/Motor_DM/: motor_dm.cpp
    ../SRML/Drivers/Devices/Motor_CyberGear/: Motor_CyberGear.cpp
  group SRML/Drivers/Devices/Log/OSAL
    ../SRML/Drivers/Devices/Log/OSAL/freertos/: osal_cond.cpp osal_misc.cpp osal_mutex.cpp osal_rwlock.cpp osal_sema.cpp osal_task.cpp
  group SRML/Drivers/Devices/Log/utils
    ../SRML/Drivers/Devices/Log/utils/: log_send.cpp misc.cpp misc_linux.cpp srml_log.cpp srml_log_linux.cpp srml_logger.cpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS_port/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Retarget_IO
    ./: stdout_user.c stdin_user.c stderr_user.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
